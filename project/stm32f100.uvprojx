# Keil uVision project stm32f100.uvprojx, settings and files
target flash (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f100 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\User\locklock
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group STDPER
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c
    ../User/usart/: debug_usart.c
    ../User/qs808/: qs808_usart.c qs808_drive.c
    ../User/Delay/: delay.c
    ../User/power/: power_ctrl.c
    ../User/data/: data_def.c
    ../User/RTC/: rtc.c
    ../User/STMFLASH/: stmflash.c
    ../User/RC522/: rc522_function.c rc522_config.c
    ../User/TIMER/: timer.c
    ../User/vcc_adc/: vcc_adc.c
    ../User/DAC/: dac.c
    ../User/led/: led.c
    ../User/UT588C/: ut588c.c
    ../User/TSM12/: TSM12.c
    ../User/BLE/: BLE.c
    ../User/RFCard/: rfcard.c
    ../User/finger/: finger.c
    ../User/password/: password.c
    ../User/gatelock/: gatelock.c
    ../User/keyboard/: keyboard.c
    ../User/oled/: oled.c
    ../User/SHA_1/: sha1.c
    ../User/NewLED/: newled.c
